<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32_h7_hse_test1.ewp</path>
  </project>
  <batchBuild />
</workspace>
